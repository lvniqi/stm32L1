# Keil uVision project project.uvproj, settings and files
target STM32L15X_EXAMPLE (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L15x_CT_Example +hex
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STMTouch_Driver\inc;..\..\..\..\Utilities\STM32_EVAL\STM32L152_TS_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../src/: system_stm32l1xx.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s
  group STM32_StdPeriph_Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_spi.c misc.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_i2c.c stm32l1xx_syscfg.c stm32l1xx_exti.c
  group STMTouch_Driver
    ../../../../Libraries/STMTouch_Driver/src/: tsl_touchkey.c tsl.c tsl_acq.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_time_stm32l1xx.c tsl_acq_stm32l1xx_sw.c
  group User
    ../src/: main.c stm32l1xx_it.c tsl_user.c
  group BOARD
    ../../../../Utilities/STM32_EVAL/STM32L152_TS_EVAL/: stm32l152_ts_eval_lcd.c stm32l152_ts_eval.c
