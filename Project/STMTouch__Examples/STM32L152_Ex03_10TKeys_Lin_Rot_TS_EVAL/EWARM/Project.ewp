# IAR project Project.ewp, settings and files
configuration STM32L1xx-EXAMPLE (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STMTouch_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL\STM32L152_TS_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM32L1xx-EXAMPLE.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BOARD
    ../../../../Utilities/STM32_EVAL/STM32L152_TS_EVAL/: stm32l152_ts_eval.c stm32l152_ts_eval_lcd.c
  group CMSIS
    ../src/: system_stm32l1xx.c
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s
  group STM32 StdPeriph Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_spi.c
  group STMTouch Driver
    ../../../../Libraries/STMTouch_Driver/src/: tsl.c tsl_acq.c tsl_acq_stm32l1xx_hw.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_time_stm32l1xx.c tsl_touchkey.c
  group User
    ../src/: main.c stm32l1xx_it.c tsl_user.c
